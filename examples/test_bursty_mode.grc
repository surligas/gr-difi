options:
  parameters:
    author: zoe
    generate_options: qt_gui
    id: test_bursty_mode
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(192, [0x0d, 0xa5, 0xe1, 0x46, 0x00, 0xb6, 0x20, 0x45, 0x19, 0x4b, 0x3b, 0x00, 0x02, 0x69, 0xe5, 0xd4, 0x4d, 0x00, 0x2d, 0x51, 0x81, 0x03, 0xe8, 0xff, 0xff, 0x6e, 0x3c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x01, 0x01, 0x42, 0x1b, 0x98, 0x00, 0x42, 0x46, 0x98, 0x00, 0x01, 0x01, 0x02, 0x01, 0xb0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4c, 0x84, 0x00, 0x00, 0x01, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00]))
    period: '1500'
  states: {}
- name: difi_sink_cpp_0
  id: difi_sink_cpp
  parameters:
    bit_depth: '8'
    context_pack_size: '108'
    context_packet_send_count: '1000'
    data_size: '672'
    length_tag_name: packet_len
    mode: burst
    gain: '1.0'
    ip_addr: 127.0.0.1
    lead_time_us: '10000'
    max_iq: '1.0'
    min_iq: '-1.0'
    offset: '0'
    port: '5003'
    protocol: '2'
    reference_time_frac: '964925050735'
    reference_time_full: '1666209080'
    sample_rate: int(samp_rate)
    scaling: '2'
    stream_id: '80000'
    type: complex
  states: {}
- name: difi_source_cpp_0
  id: difi_source_cpp
  parameters:
    bit_depth: '8'
    context_behavior: '0'
    ip_addr: 127.0.0.1
    port: '5003'
    protocol: '2'
    stream_num: '80000'
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*32
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_pdu_to_tagged_stream_0, pdus]
- [difi_source_cpp_0, '0', qtgui_time_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', difi_sink_cpp_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
